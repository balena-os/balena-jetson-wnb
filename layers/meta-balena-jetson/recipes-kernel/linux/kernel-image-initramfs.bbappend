do_install_append() {
   install -m 0644 ${DEPLOY_DIR_IMAGE}/tegra186-quill-p3310-1000-c03-00-base_apollo.dtb ${D}/boot/tegra186-quill-p3310-1000-c03-00-base_apollo.dtb
}
