TTYS_jetson-tx2=" ttyS0 tty1"
