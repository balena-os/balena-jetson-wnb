PACKAGE_INSTALL_append = " tegra-firmware-xusb kernel-module-bcmdhd"
