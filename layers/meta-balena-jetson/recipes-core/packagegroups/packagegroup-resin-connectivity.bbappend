# The machine in this repo is still on kernel < 4.15 so let's not use wireless-regdb-static just yet
CONNECTIVITY_FIRMWARES_remove = "wireless-regdb-static"
